<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RT6037(3D).ewp</path>
  </project>
  <batchBuild/>
</workspace>


