# IAR project RT8600S_Bootload.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG280F128 EnergyMicro EFM32LG280F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32LG280F128; NDEBUG
  ICCARM.CCIncludePath2: Include; Device\EnergyMicro\EFM32G\Include; Device\EnergyMicro\EFM32LG\Include; src; emlib\inc; config_gecko; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RT6037S_Bootload_Leuart_0x18000_20170815.bin
  ILINK.IlinkOutputFile: G280_Bootload.out
  ILINK.IlinkIcfFile: G280_Bootload.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: bootloader.c
  group CMSIS
    Device/EnergyMicro/EFM32G/Source/IAR/: startup_efm32g.s
    Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group Driver
    src/: boot.c crc.c debuglock.c flash.c iarwrite.c usart.c xmodem.c xmodemleuart.c
  group emlib
    emlib/src/: em_assert.c em_cmu.c em_dbg.c em_dma.c em_emu.c em_gpio.c em_int.c em_leuart.c em_msc.c em_rtc.c em_system.c em_usart.c em_vcmp.c em_wdog.c
